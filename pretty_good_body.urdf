Commit message: long NEAT working

File: pretty_good_body.urdf (robot description, URDF)
Before this commit: robot robot, 9 links, 8 joints
Links:
- link Torso: mass 10.0 -> 1.0
